# Keil uVision project Lab16_IoT_K5V.uvprojx, settings and files
target IoT_Wifi_Coms (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab16_IoT_K5V
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CC3100;..\CC3100\platform\ek-tm4c123gxl;..\CC3100\simplelink;..\CC3100\simplelink\include;..\..\TM4C123Valvanoware
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_rvmdk.S main.c LED.c Nokia5110.c
